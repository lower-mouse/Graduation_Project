<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>4</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>4</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <group>
    <name>HARDWARE</name>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\ADC\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\BLE\ble.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\COMPUTATION\computation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\EEPROM\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\ENCRPYT\encrpyt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\FAKONG\fakong.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\LCD\LCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\RTC\rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\HARDWARE\UART\stm8l_uart.c</name>
    </file>
  </group>
  <group>
    <name>STM8L15x_StdPeriph_Driver</name>
    <group>
      <name>SYSTEM</name>
      <file>
        <name>$PROJ_DIR$\..\SYSTEM\system.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l15x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l15x_it.h</name>
    </file>
  </group>
</project>


