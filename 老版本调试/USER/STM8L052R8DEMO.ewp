# IAR project STM8L052R8DEMO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\HARDWARE\ADC; ..\HARDWARE\COMPUTATION; ..\HARDWARE\EEPROM; ..\HARDWARE\ENCRPYT; ..\HARDWARE\FAKONG; ..\HARDWARE\FLASH; ..\HARDWARE\LCD; ..\HARDWARE\LED; ..\HARDWARE\RTC; ..\HARDWARE\UART; ..\STM8L15x_StdPeriph_Driver\inc; ..\SYSTEM; C:\Users\prepare\Desktop\Version2\SYSTEM
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\HARDWARE\FLASH; D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\HARDWARE\LCD; D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\HARDWARE\LED; D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\HARDWARE\UART; D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\SYSTEM; D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\STM8L15x_StdPeriph_Driver\inc; D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\STM8L15x_StdPeriph_Driver\src; D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\USER\settings; D:\项目\STM8资料\STM8资料\项目程序stm8\张斌的程序1\STM8L052R8\USER; D:\项目\STM8资料\STM8资料\项目程序stm8\RTC不准加入计量\STM8L052R8\HARDWARE\FAKONG; D:\项目\STM8资料\STM8资料\项目程序stm8\加入协议3\HARDWARE\ADC; D:\项目\STM8资料\STM8资料\项目程序stm8\加入协议3\HARDWARE\RTC; D:\项目\STM8资料\STM8资料\项目程序stm8\加入协议4\HARDWARE\ENCRPYT
  OBJCOPY.OOCOutputFile: STM8L052R8DEMO.srec
  ILINK.IlinkOutputFile: STM8L052R8DEMO.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 1
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\USER; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\SYSTEM; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\STM8L15x_StdPeriph_Driver\inc; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\STM8L15x_StdPeriph_Driver\src; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\ADC; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\BLE; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\COMPUTATION; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\EEPROM; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\ENCRPYT; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\FAKONG; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\LCD; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\RTC; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\UART
  ASTM8.AsmIncludePath: C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\UART; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\LCD; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\RTC; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\FAKONG; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\ENCRPYT; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\EEPROM; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\COMPUTATION; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\BLE; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\HARDWARE\ADC; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\STM8L15x_StdPeriph_Driver\inc; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\STM8L15x_StdPeriph_Driver\src; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\SYSTEM; C:\Users\john\Desktop\蓝牙水表下位机程序源码\老版本调试\USER
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BLE/: ble.c
    ../HARDWARE/COMPUTATION/: computation.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/ENCRPYT/: encrpyt.c
    ../HARDWARE/FAKONG/: fakong.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/UART/: stm8l_uart.c
  group STM8L15x_StdPeriph_Driver
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c
  group STM8L15x_StdPeriph_Driver/SYSTEM
    ../SYSTEM/: system.c
  group USER
    ./: main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
